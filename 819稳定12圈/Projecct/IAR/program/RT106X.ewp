# IAR project RT106X.ewp, settings and files
configuration nor_sdram_zf_dtcm (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1064DVL6A; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\CODE; ..\..\..\Libraries\librares\CMSIS\Include; ..\..\..\Libraries\librares\cmsis_drivers; ..\..\..\Libraries\librares\drives; ..\..\..\Libraries\librares\startup; ..\..\..\Libraries\librares\startup\IAR-ARM; ..\..\..\Libraries\librares\utilities; ..\..\..\Libraries\librares\utilities\debug_console; ..\..\..\Libraries\librares\utilities\str; ..\..\..\Libraries\librares\xip; ..\..\..\Libraries\seekfree_librares; ..\..\..\Libraries\seekfree_peripheral; ..\..\..\Libraries\librares\components\serial_manager; ..\..\..\Libraries\librares\components\serial_manager\usb_cdc_adapter; ..\..\..\Libraries\librares\components\uart; ..\..\..\Libraries\librares\components\lists; ..\..\..\Libraries\librares\deceive; ..\..\..\Libraries\seekfree_librares\common; ..\..\..\Libraries\seekfree_librares\board; ..\src\common; D:\led闪烁（gpio）\Projecct\IAR\src; D:\led闪烁（gpio）\Projecct\IAR\src\common; D:\led闪烁（gpio）\Projecct\IAR\src\board; D:\led闪烁（gpio）\Projecct\IAR\src\eMPL; D:\led闪烁（gpio）\Projecct\CODE\usb\device; D:\led闪烁（gpio）\Projecct\CODE\usb\include; D:\led闪烁（gpio）\Projecct\CODE\usb\osa; D:\led闪烁（gpio）\Projecct\CODE\usb\phy; ..\..\CODE\usb\device; ..\..\CODE\usb\osa; ..\..\CODE\usb\phy; ..\src\board; ..\src\common; ..\src\eMPL; ..\src; ..\..\CODE\usb\include; ..\src\M8266WIFI; ..\src\SYSTEM\sys; ..\src\SYSTEM\delay
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..\..\..\Libraries\librares\startup\IAR-ARM; D:\led闪烁（gpio）\Projecct
  OBJCOPY.OOCOutputFile: RT106X.srec
  ILINK.IlinkOutputFile: RT106X.out
  ILINK.IlinkIcfFile: ..\..\IAR\icf\MIMXRT1064xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../src/: 2021TJU.c car_global.h
  group app/car_init
    ../src/: car_init.c car_init.h
  group app/car_isr
    ../src/: car_isr.c car_isr.h
  group app/data
    ../src/: data.h data_input.c data_output.c data_process.c data_save.c outputdata.c outputdata.h
    ../../../Libraries/app/: data_process.h
  group app/display
    ../src/: ips200.c ips200.h ips_display.c ips_display.h
  group app/sensor/camera
    ../src/: camera.c camera.h camera_process.c camera_process.h dynamic_persp.c dynamic_persp.h
  group app/setpara
    ../src/: setpara.c setpara.h
  group app/Send
    ../src/: uart_dma.c uart_dma.h uart_wave.c uart_wave.h
  group board
    ../../../Libraries/seekfree_librares/board/: board.c board.h clock_config.c pin_mux.c
  group common
    ../src/common/: flash.c flash.h gpio_cfg.h rom_api.c rom_api.h seekfree_printf.c seekfree_printf.h usb_cdc.c usb_cdc.h vector.c vector.h wave.c wave.h
  group components
    ../../../Libraries/librares/components/lists/: generic_list.c generic_list.h
    ../../../Libraries/librares/components/uart/: lpuart_adapter.c uart.h
    ../../../Libraries/librares/components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group deceive
    ../../../Libraries/librares/deceive/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
  group doc
    ../../../Libraries/doc/: read me.txt version.txt
  group drives
    ../../../Libraries/librares/drives/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.c fsl_aoi.h fsl_bee.c fsl_bee.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flexcan.c fsl_flexcan.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_flexspi.c fsl_flexspi.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_kpp.c fsl_kpp.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_semc.c fsl_semc.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.c fsl_spdif.h fsl_spdif_edma.c fsl_spdif_edma.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_tsc.c fsl_tsc.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group seekfree_librares
    ../../../Libraries/seekfree_librares/common/: common.c common.h seekfree_printf.h
    ../../../Libraries/seekfree_librares/: zf_adc.c zf_adc.h zf_camera.c zf_camera.h zf_gpio.c zf_gpio.h zf_iic.c zf_iic.h zf_iomuxc.c zf_iomuxc.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_qtimer.c zf_qtimer.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_uart.c zf_uart.h
  group seekfree_peripheral
    ../../../Libraries/seekfree_peripheral/: SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_OLED.c SEEKFREE_OLED.h
  group startup
    ../../../Libraries/librares/startup/IAR-ARM/: startup_MIMXRT1064.s
  group usb_cdc
    ../../CODE/usb/device/: usb_device.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_dci.c usb_device_dci.h usb_device_descriptor.c usb_device_descriptor.h usb_device_ehci.c usb_device_ehci.h
    ../../CODE/usb/include/: usb_misc.h usb_spec.h
    ../../CODE/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
    ../../CODE/usb/phy/: usb_phy.c usb_phy.h
  group user_h
    ../../../Libraries/seekfree_librares/: headfile.h
    ../../USER/inc/: RT106X_config.h
  group utilities
    ../../../Libraries/librares/utilities/: fsl_assert.c fsl_notifier.c fsl_notifier.h fsl_sbrk.c fsl_shell.c fsl_shell.h usb_device_config.h
    ../../../Libraries/librares/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../Libraries/librares/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../Libraries/librares/xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
